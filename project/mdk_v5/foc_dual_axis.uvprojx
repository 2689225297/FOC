# Keil uVision project foc_dual_axis.uvprojx, settings and files
target FOC_DualAxis_Debug (6210000::V6.21::ARMCLANG)
  device: -AT32F403ACGU7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.2.4
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FOC_DualAxis_Debug +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AT32F403ACGU7,USE_STDPERIPH_DRIVER
  c misc: -std=c11 -g -O0
  c include: ..\..\inc;..\..\inc\app;..\..\inc\bsp;..\..\inc\comm;..\..\inc\motor;..\..\inc\safety;..\..\inc\storage;..\..\inc\test;..\..\vendor\ARM_CMSIS\6.3.0\CMSIS\Core\Include;..\..\vendor\AT32F403A_407_DFP\2.2.4\Device\Include;..\..\vendor\AT32F403A_407_DFP\2.2.4\Device\Firmware\Peripherals\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: .\foc_dual_axis.sct
  group main
    ../../src/: main.c at32f403a_407_int.c
  group app
    ../../src/app/: app_init.c app_scheduler.c app_state_machine.c app_control_core.c app_profiling.c
  group bsp
    ../../src/bsp/: bsp_clock.c bsp_current_sense.c bsp_drv8323.c bsp_flash.c bsp_log.c bsp_nfault.c bsp_pwm.c bsp_pwm_math.c bsp_safe_outputs.c bsp_time.c bsp_watchdog.c
  group comm
    ../../src/comm/: comm_guard.c
  group safety
    ../../src/safety/: safety_fault.c safety_speed.c
  group motor
    ../../src/motor/: motor_axis.c motor_current.c motor_math.c motor_transform.c motor_svpwm.c motor_pi.c motor_if.c motor_hfi.c motor_flux.c motor_smo.c motor_ekf.c motor_observer.c motor_control.c motor_startup.c motor_control_path.c
  group storage
    ../../src/storage/: storage_crc32.c storage_parameter.c storage_transaction.c
  group test
    ../../src/test/: test_a4_no_power.c test_self_check.c test_profiling.c
  group firmware
    ../../vendor/AT32F403A_407_DFP/2.2.4/Device/Firmware/Peripherals/src/: at32f403a_407_adc.c at32f403a_407_bpr.c at32f403a_407_can.c at32f403a_407_crc.c at32f403a_407_crm.c at32f403a_407_dac.c at32f403a_407_debug.c at32f403a_407_dma.c at32f403a_407_exint.c at32f403a_407_flash.c at32f403a_407_gpio.c at32f403a_407_i2c.c at32f403a_407_misc.c at32f403a_407_pwc.c at32f403a_407_rtc.c at32f403a_407_sdio.c at32f403a_407_spi.c at32f403a_407_tmr.c at32f403a_407_usart.c at32f403a_407_usb.c at32f403a_407_wdt.c at32f403a_407_wwdt.c at32f403a_407_xmc.c
  group cmsis
    ../../vendor/AT32F403A_407_DFP/2.2.4/Device/Source/: system_at32f403a_407.c
    ../../vendor/AT32F403A_407_DFP/2.2.4/Device/Source/ARM/: startup_at32f403a_407.s
target FOC_DualAxis_Release (6210000::V6.21::ARMCLANG)
  device: -AT32F403ACGU7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.2.4
  cpu: as above
  output: FOC_DualAxis_Release +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AT32F403ACGU7,USE_STDPERIPH_DRIVER
  c misc: -std=c11 -Werror
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: .\foc_dual_axis.sct
